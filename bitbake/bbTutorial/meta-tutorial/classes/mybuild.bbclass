addtask build
mybuild_do_build () {
     
      echo "running mybuild_do_build."
           
}
 
EXPORT_FUNCTIONS do_build
