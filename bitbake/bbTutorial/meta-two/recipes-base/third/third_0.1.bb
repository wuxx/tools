DESCRIPTION = "I am the third recipe"
PR = "r1"
inherit confbuild
